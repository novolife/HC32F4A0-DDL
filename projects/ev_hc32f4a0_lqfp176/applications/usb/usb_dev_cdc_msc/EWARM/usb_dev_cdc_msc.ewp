# IAR project usb_dev_cdc_msc.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include; ../../../../../../drivers/cmsis/Include; ../../../../../../drivers/hc32_ll_driver/inc; ../../../../../../drivers/bsp/components/tca9539; ../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176; ../../../../../../midwares/hc32/usb; ../../../../../../midwares/hc32/usb/usb_device_lib/device_core; ../../../../../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc; ../../../../../../midwares/hc32/usb/usb_device_lib/device_class/msc; ../../../../../../midwares/hc32/usb/usb_device_lib/device_class/cdc_msc_composite; ../../../../../../midwares/hc32/sdioc/sd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_dev_cdc_msc.hex
  ILINK.IlinkOutputFile: usb_dev_cdc_msc.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F4A0_2M_= 1
  ILINK.IlinkIcfFile: config/linker/HC32F4A0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group cmsis
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ./: startup_hc32f4a0.s
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sdioc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c
  group bsp/components/tca9539
    ../../../../../../drivers/bsp/components/tca9539/: tca9539.c
  group bsp/ev_hc32f4a0_lqfp176
    ../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_tca9539.c
  group midwares/usb/usb_device_lib/device_core
    ../../../../../../midwares/hc32/usb/usb_device_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
  group midwares/usb/usb_device_lib/device_class/single_cdc
    ../../../../../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc/: usb_dev_cdc_class.c
  group midwares/usb/usb_device_lib/device_class/msc
    ../../../../../../midwares/hc32/usb/usb_device_lib/device_class/msc/: usb_dev_msc_bot.c usb_dev_msc_class.c usb_dev_msc_data.c usb_dev_msc_scsi.c
  group midwares/usb/usb_device_lib/device_class/cdc_msc_composite
    ../../../../../../midwares/hc32/usb/usb_device_lib/device_class/cdc_msc_composite/: usb_dev_cdc_msc_wrapper.c
  group midwares/sdioc/sd
    ../../../../../../midwares/hc32/sdioc/sd/: sd.c
  group source
    ../source/: main.c cdc_data_process.c sd_card.c usb_bsp.c usb_dev_desc.c usb_dev_msc_msd.c usb_dev_user.c
