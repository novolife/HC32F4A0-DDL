# IAR project iec60730_class_b.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include; ../../../../../../drivers/cmsis/Include; ../../../../../../drivers/hc32_ll_driver/inc; ../source/test_impl_item; ../../../../../../drivers/bsp/components/tca9539; ../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176; ../../../../../../midwares/hc32/iec60730_class_b_stl; ../../../../../../midwares/hc32/iec60730_class_b_stl/stl_test_item/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iec60730_class_b.hex
  ILINK.IlinkOutputFile: iec60730_class_b.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F4A0_2M_= 1
  ILINK.IlinkIcfFile: config/linker/HC32F4A0.icf
  ILINK.IlinkExtraOptions: --fill 0xFF;0x00000000-0x001FFFFF; --checksum __checksum:4,crc32:1mi,0xFFFFFFFF;0x00000000-0x001FFFFB
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group cmsis
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ./: startup_hc32f4a0.s
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_clk.c hc32_ll_dbgc.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c
  group bsp/components/tca9539
    ../../../../../../drivers/bsp/components/tca9539/: tca9539.c
  group bsp/ev_hc32f4a0_lqfp176
    ../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_tca9539.c
  group midwares/iec60730_class_b_stl
    ../../../../../../midwares/hc32/iec60730_class_b_stl/: stl_test_runtime.c stl_utility.c
  group midwares/iec60730_class_b_stl/stl_test_item
    ../../../../../../midwares/hc32/iec60730_class_b_stl/stl_test_item/src/: m4_iec60730_class_b_stl.a stl_sw_crc32.c stl_test_interrupt.c
  group source
    ../source/: main.c runtime_test.c startup_test.c
  group source/test_impl_item
    ../source/test_impl_item/: test_impl_adc.c test_impl_clk.c test_impl_flash.c test_impl_gpio.c test_impl_interrupt.c test_impl_ram.c test_impl_wdt.c
