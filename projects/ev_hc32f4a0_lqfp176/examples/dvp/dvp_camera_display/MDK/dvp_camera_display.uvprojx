# Keil uVision project dvp_camera_display.uvprojx, settings and files
target dvp_camera_display_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.9
  cpu: IROM1(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: dvp_camera_display +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,
  c include: ../source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/components/nt35510;../../../../../../drivers/bsp/components/ov5640;../../../../../../drivers/bsp/components/tca9539;../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f4a0.s
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group source
    ../source/: main.c
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_dvp.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_smc.c hc32_ll_sram.c hc32_ll_utility.c
  group nt35510
    ../../../../../../drivers/bsp/components/nt35510/: nt35510.c
  group ov5640
    ../../../../../../drivers/bsp/components/ov5640/: ov5640.c
  group tca9539
    ../../../../../../drivers/bsp/components/tca9539/: tca9539.c
  group ev_hc32f4a0_lqfp176
    ../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_nt35510.c ev_hc32f4a0_lqfp176_ov5640.c ev_hc32f4a0_lqfp176_tca9539.c
  group Readme
    ../: Readme.txt
target dvp_camera_display_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.9
  cpu: as above
  output: dvp_camera_display +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F4A0,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/components/nt35510;../../../../../../drivers/bsp/components/ov5640;../../../../../../drivers/bsp/components/tca9539;../../../../../../drivers/bsp/ev_hc32f4a0_lqfp176;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
